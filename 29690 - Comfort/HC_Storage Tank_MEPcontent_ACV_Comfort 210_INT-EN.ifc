Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2021-05-25T15:01:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 25 15:01:16 2021 * Host: RVIDREA-RO-LE * Database: C:\Users\RVidrea\AppData\Local\Temp\{919330EF-D481-4EE0-8CA8-2D8BFACECC8D}\ifc * Database version: 5507 * Database creation date: Tue May 25 15:01:15 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue May 25 15:01:16 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 25 15:01:16 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcTank: Comfort 210, HC_Storage Tank_MEPcontent_ACV_Comfort_100-240_INT-EN:Comfort 210:1348202
In: V00
Type - Material: Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 040-040-040, Color RGB 000-000-255, Color RGB 255-000-000, Color RGB 073-073-073
Type - Dimensions - Depth: 525 mm; Domestic Cold Water Diameter: 19.05 mm; Domestic Hot Water Diameter: 19.05 mm; Height: 1475 mm; Hydronic Return Diameter: 25.4 mm; Hydronic Supply Diameter: 25.4 mm; Use Nominal Diameter: yes; Width: 525 mm
Type - Electrical - Frequency: 50 Hz; Rated Current (Fuse): 6 A; Voltage: 230 V
Type - Identity Data - Article Type: Comfort 210; Base Family Version: 12.27; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Multiposition tank. Can be placed on the floor or on the wall preferably vertically; EMCS Version: 4.0; ETIM Article Class: EC011392; Family Version: 12.26; GLN: 5400891000007; Manufacturer: ACV; Manufacturer URL: https://www.acv.com/international/customer/dl/496; MEPcontent Class: STORAGE_TANK_HC; Model: Comfort 210; OmniClass Number: 23.75.10.34.11; OmniClass Title: Energy Storage Tanks; Revit Version: 2018; Type Name: Comfort 210; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-000-255; Grey: Color RGB 073-073-073; Red: Color RGB 255-000-000; White: Color RGB 222-222-222
Type - Mechanical - DHW Continuous Flow 60°C: 0.00016 m3/s; Maximum Supply Temperature (Operating Temperature): 90 kg/K/s3; Max Pressure DHW: 860000 Pa; Max Pressure Heating: 300000 Pa; Total Capacity: 0.203 m3; Weight: 58
Type - Other - Category: Mechanical Equipment; Family Name: HC_Storage Tank_MEPcontent_ACV_Comfort_100-240_INT-EN; Return Connector Height: 215 mm; Storage Energy Efficiency Class: C; Suply Connector Height: 1210 mm
Type - Text - Article Description: Multiposition tank. Can be placed on the floor or on the wall preferably vertically; GTIN: 5400891001998; Manufacturer Art. No.: 06631501; Pipe Type Category: M561; Product Line: Comfort
Pset_ManufacturerTypeInformation - Manufacturer: ACV
Constraints - Offset: 0 mm
Dimensions - Area: 4.32248 m2; Volume: 0.29354 m3
Identity Data - Mark: 4
Mechanical - Domestic Cold Water Flow: 0 m3/s; Domestic Hot Water Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Domestic Cold Water,Domestic Hot Water,Hydronic Return,Hydronic Supply
Other - Back Clerance Safe: 50 mm; Family: HC_Storage Tank_MEPcontent_ACV_Comfort_100-240_INT-EN: Comfort 210; Family and Type: HC_Storage Tank_MEPcontent_ACV_Comfort_100-240_INT-EN: Comfort 210; Left Clerance Safe: 500 mm; Type: HC_Storage Tank_MEPcontent_ACV_Comfort_100-240_INT-EN: Comfort 210; Type Id: HC_Storage Tank_MEPcontent_ACV_Comfort_100-240_INT-EN: Comfort 210
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 50 mm; Left Clearance: 500 mm; Service Space: no
